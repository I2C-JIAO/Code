# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,NDEBUG,HSE_VALUE=8000000
  c include: ..\firmware\driver\inc;..\firmware\cmsis\core;..\firmware\cmsis\device;..\app\inc;..\driver\led;..\driver\delay;..\driver\usart;..\third_lib\lettershell;..\app\commands;..\third_lib\ringbuffer;..\third_lib\tlsf;..\third_lib\easylogger\inc;..\third_lib\easylogger\port;..\third_lib\easylogger\src;..\app\manage;..\driver\dht11;..\driver\lcd;..\third_lib\freeRTOS\include;..\third_lib\freeRTOS\portable\RVDS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c
    ../app/inc/: main.h board.h
  group app/override
    ../app/override/: malloc.c
  group app/manage
    ../app/manage/: log_manage.c mem_manage.c
  group app/shell_commands
    ../app/commands/: helloworld.c add.c mem.c log.c mydht11.c
  group driver
    ../driver/led/: led.c led.h
    ../driver/delay/: delay.c
    ../driver/usart/: my_usart.c
    ../driver/dht11/: dht11.c
    ../driver/lcd/: lcd.c
  group firmware
    ../firmware/cmsis/core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../firmware/driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/lettershell
    ../third_lib/lettershell/: shell.c shell_cmd_list.c shell_ext.c
  group third_lib/ringbuffer
    ../third_lib/ringbuffer/: ringbuffer8.c
  group third_lib/tlsf
    ../third_lib/tlsf/: tlsf.c
  group third_lib/easylogger
    ../third_lib/easylogger/port/: elog_port.c
    ../third_lib/easylogger/src/: elog.c elog_utils.c
  group third_lib/freeRTOS
    ../third_lib/freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/freeRTOS/portable/RVDS/: port.c
    ../third_lib/freeRTOS/portable/MemMang/: heap_4.c
